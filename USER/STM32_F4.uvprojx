# Keil uVision project STM32_F4.uvprojx, settings and files
target bridge_torque (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32_F4 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\STM32F4x7_ETH_Driver\inc;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\MODULES\inc;..\USER;..\MODULES\fatfs\inc;..\MODULES\eth\lwip_app\inc;..\MODULES\eth\lwip-1.4.1\src\include;..\MODULES\eth\lwip-1.4.1\src\include\ipv4;..\MODULES\eth;..\MODULES\USB\USB_APP;..\MODULES\USB\STM32_USB_OTG_Driver\inc;..\MODULES\USB\STM32_USB_HOST_Library\Core\inc;..\MODULES\USB\STM32_USB_HOST_Library\Class\MSC\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../user/: main.c stm32f4xx_it.c
    ../USER/: system_stm32f4xx.c startup_stm32f40_41xxx.s
    ./: stm32f4xx_conf.h
  group MODULES
    ../MODULES/adc/: ads1258.c spi.c
    ../MODULES/delay/: delay.c
    ../MODULES/sys/: sys.c
    ../MODULES/uart/: usart.c
    ../MODULES/malloc/: malloc.c
    ../MODULES/sd/: sdio_sdcard.c
    ../MODULES/eth/: lan8720.c
    ../MODULES/timer/: timer.c
    ../MODULES/exti/: exti.c
    ../MODULES/rtc/: rtc.c
    ../MODULES/gpio/: gpio.c
    ../MODULES/flash/: stmflash.c
    ../MODULES/initstate/: initstate.c
    ../MODULES/lcd12864/: lcd12864.c
  group FATFS
    ../MODULES/fatfs/src/: diskio.c ff.c cc936.c exfuns.c fatfs_api.c
  group FWLIB
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group LWIP_APP
    ../MODULES/eth/lwip_app/lwip_comm/: lwip_comm.c
    ../MODULES/eth/lwip_app/tcp_client_demo/: tcp_client_demo.c
    ../MODULES/eth/lwip_app/tcp_server_demo/: tcp_server_demo.c
    ../MODULES/eth/lwip_app/udp_demo/: udp_demo.c
    ../MODULES/eth/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
  group LWIP_ARCH
    ../MODULES/eth/arch/: sys_arch.c
  group LWIP_CORE
    ../MODULES/eth/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../MODULES/eth/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP_API
    ../MODULES/eth/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_NETIF
    ../MODULES/eth/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group USB_OTG
    ../MODULES/USB/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_core.c usb_hcd.c
  group USB_HOST
    ../MODULES/USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../MODULES/USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USP_APP
    ../MODULES/USB/USB_APP/: usbh_usr.c usb_bsp.c
software components: CMSIS:CORE 3.40.0
